# Keil uVision project ble_command_encoder_cunit.uvproj, settings and files
target toxophilite (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cunit_test
  c flags: Optim=1 wLevel=2
  c define: NRF51 NRF51822_QFAA_CA BOARD_NRF6310 SVCALL_AS_NORMAL_FUNCTION
  c misc: --diag_suppress 177 --diag_suppress 170 --c99
  c include: ..\..\..\..\..\..\..\framework\cunit\keil_include_overwrite;..\..\..\..\..\Include;..\..\..\..\..\..\..\framework\cunit;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\ble\rpc;..\..\..\..\..\Include\app_common\mock;..\..\..\..\..\Include\stm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20004000
  link misc: --remove
  group Testbench
    ./: cunit_test.c
    ./: cunit_test_gap.c cunit_test_gatts.c
  group core
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../../framework/cunit/: system_nrf51.c
  group module
    ../../: ble_rpc_cmd_encoder.c ble_rpc_cmd_encoder_gap.c ble_rpc_cmd_encoder_gatts.c
  group framework
    ../../../../../../../framework/cunit/: nrf_cunit.c nrf_cunit_mock.c uart.c
    ../../../../app_common/mock/hci_transport/: hci_transport_mock.c

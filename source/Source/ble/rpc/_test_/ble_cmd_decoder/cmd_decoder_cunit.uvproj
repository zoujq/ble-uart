# Keil uVision project cmd_decoder_cunit.uvproj, settings and files
target test_cmd_decoder_gap (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cunit_test
  c flags: Optim=4 oTime=1
  c define: NRF51 NRF51822_QFAA_CA BOARD_NRF6310 SDM_LOG_GPIO SVCALL_AS_NORMAL_FUNCTION
  c misc: --diag_suppress 177 --c99
  c include: ..\..\..\..\..\Include;..\..\..\..\..\..\..\framework\cunit;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\ble\rpc;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\app_common\mock;..\..\..\..\..\Include\stm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x20008000
  link misc: --remove
  group Testbench
    ./: cunit_test.c
    ./: cunit_test_gap.c cunit_test_gatts.c cunit_test_misc.c
  group core
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../../framework/cunit/: system_nrf51.c
  group module
    ../../: ble_rpc_cmd_decoder.c ble_rpc_cmd_decoder_gap.c ble_rpc_cmd_decoder_gatts.c
  group framework
    ../../../../../../../framework/cunit/: nrf_cunit.c uart.c nrf_cunit_mock.c
    ../../../../app_common/mock/hci_transport/: hci_transport_mock.c
    ../mock/softdevice/: ble_stack_gap_mock.c ble_stack_gatts_mock.c ble_stack_weak.c ble_stack_mock.c
target test_cmd_decoder_gatts (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cunit_test
  c flags: Optim=2
  c define: as above
  c misc: --diag_suppress 177 --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x20008000
  link misc: --remove
target test_cmd_decoder_misc (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cunit_test
  c flags: Optim=1
  c define: as above
  c misc: --diag_suppress 177 --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x20008000
  link misc: --remove
